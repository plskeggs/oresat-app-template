## Kconfig
```kconfig
menu "Zephyr"
source "Kconfig.zephyr"
endmenu

module = APP_TEMPLATE
module-str = APP TEMPLATE
```
